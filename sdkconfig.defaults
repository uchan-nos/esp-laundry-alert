## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_CONNECT_WIFI=y
# CONFIG_EXAMPLE_CONNECT_ETHERNET is not set

CONFIG_ESP32_ULP_COPROC_ENABLED=y
```
